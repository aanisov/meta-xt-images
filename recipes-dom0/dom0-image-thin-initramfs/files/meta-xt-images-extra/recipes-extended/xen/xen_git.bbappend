PACKAGES_append = "\
    ${PN}-libxendevicemodel \
    ${PN}-libxendevicemodel-dev \
    "
